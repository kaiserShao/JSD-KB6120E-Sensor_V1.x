# Keil uVision project KB6120-Sensor.uvproj, settings and files
target KB6120-Sensor (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: KB6120E-Sensor +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG
  c include: ..\BSP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MODBUS
    ../modbus/: mb.c
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbutils.c
    ../bsp/: mbfuncother.c
    ../modbus/rtu/: mbcrc.c mbrtu.c
    ../modbus/ascii/: mbascii.c
    ../modbus/tcp/: mbtcp.c
    ../BSP/: MODBUS-Port-STM32.C
  group App
    ../BSP/: startup_stm32f10x_md_vl.s BIOS.C AD7705.C FM24.C SENSOR.C DS18B20.C HCBoxS.c
  group MainX
    ../: main_KB6120C-Sensor.c
  group NOTE
    ../: note.txt
